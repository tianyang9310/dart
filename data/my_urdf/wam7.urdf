Commit message: set up operational space control

File: data/my_urdf/wam7.urdf (robot description, URDF)
Before this commit: robot wam, 10 links, 9 joints
Joints:
- joint wam/wam_fixed_joint: origin xyz=0.0 0.0 1.0 rpy=0 0 0 -> xyz=0.0 0.0 0.0 rpy=0 0 0
